# Keil uVision project template.uvprojx, settings and files
target template (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: PT3220-Hxxx PTW
  pack: PTW.PT3220.1.1.0
  cpu: CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: template +hex
  AfterMake: fromelf.exe  --bin -o "$L@L.bin" "#L"
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --c99 --gnu --thumb --bss_threshold=0
  asm misc: --thumb
  library: MicroLIB
  scatter file: .\link_xip.sct
  link misc: --diag_suppress=L6312,L6314,L6329
  group core
    ./: startup.s
  group drivers
    ../platform/drivers/api/: drvs.h
    ../platform/drivers/lib/: drvs.lib
